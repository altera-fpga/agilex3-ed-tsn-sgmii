FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
LICENSE = "BSD-3-Clause"

SRC_URI:append:agilex3 = " file://0001-SM-TSN-CFG3-changes-for-TSN-REF-App.patch "
